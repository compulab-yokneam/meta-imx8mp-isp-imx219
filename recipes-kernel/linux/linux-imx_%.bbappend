FILESEXTRAPATHS:prepend := "${THISDIR}/imx219:"

SRC_URI += "file://0001-linux-kernel-remove-IMX219-cfg.patch"
